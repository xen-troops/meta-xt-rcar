# remove not used file types, added by
# meta-rcar-gen3/conf/machine/include/rcar_common.inc
IMAGE_FSTYPES:remove="wic.xz wic.bmap wic.xz.sha256sum"
