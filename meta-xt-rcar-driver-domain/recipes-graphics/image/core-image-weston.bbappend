IMAGE_INSTALL:append = " \
    preinit-weston \
"
