RENESAS_BSP_URL = "git://github.com/xen-troops/linux.git"

BRANCH = "v5.10.41/rcar-5.1.4.1-xt0.2"
SRCREV = "bf7d6bcdd618e5acb21118d87c76e5d8913f8dde"
LINUX_VERSION = "5.10.41"
