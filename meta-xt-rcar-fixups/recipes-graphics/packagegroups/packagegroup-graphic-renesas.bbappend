RDEPENDS_packagegroup-graphics-renesas-wayland_remove = " \
    wayland-wsegl \
"
