
FILES_${PN}_remove = " \
    /lib/firmware/rgx.sh* \
"
