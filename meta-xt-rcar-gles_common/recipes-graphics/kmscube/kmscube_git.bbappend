FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0001-texturator-Use-correct-GL-extension-header.patch \
"
