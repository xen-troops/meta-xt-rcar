FILESEXTRAPATHS:prepend := "${THISDIR}/files-2022:"

SRC_URI += " \
    file://0001-net-rswtich-disable-GWCA-when-removing-driver.patch \
"
